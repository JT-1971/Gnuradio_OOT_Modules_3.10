options:
  parameters:
    author: Serge G
    category: Custom
    description: Constellation+MER+Spectrum (all blocks are extracted)
    generate_options: qt_gui
    id: dab_whole_graph
    output_language: python
    title: DAB Measurement tool
  states: {}

blocks:
- name: cp_gap__
  id: variable
  parameters:
    value: '[30, 10, 5, 20]'
  states: {state: disabled}
- name: cp_gap__
  id: variable
  parameters:
    value: '[252, 63, 31, 124]'
  states: {}
- name: cp_length__
  id: variable
  parameters:
    value: '[504, 126, 63, 252]'
  states: {}
- name: dab_mode
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fft_length__
  id: variable
  parameters:
    value: '[2048, 512, 256, 1024]'
  states: {}
- name: frame_length__
  id: variable
  parameters:
    value: '[196608, 49152, 49152, 98304]'
  states: {}
- name: ns_length__
  id: variable
  parameters:
    value: '[2656, 664, 345, 1328]'
  states: {}
- name: num_carriers__
  id: variable
  parameters:
    value: '[1536, 384, 192, 768]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: symbol_length__
  id: variable
  parameters:
    value: '[2552, 638, 319, 1276]'
  states: {}
- name: symbols_for_ffs_estimation__
  id: variable
  parameters:
    value: '[8,8,16,8]'
  states: {}
- name: symbols_for_magnitude_equalization__
  id: variable
  parameters:
    value: '[6,6,12,6]'
  states: {}
- name: symbols_per_frame__
  id: variable
  parameters:
    value: '[76, 76, 153, 76]'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: (fft_length__[dab_mode-1]+cp_length__[dab_mode-1])*symbols_for_ffs_estimation__[dab_mode-1]
    minoutbuf: '4096'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_peak_detector_xb_0_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.0001'
    look_ahead: '10'
    threshold_factor_fall: '0.7'
    threshold_factor_rise: '0.6'
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: dab_control_stream_to_tag_cc_0
  id: dab_control_stream_to_tag_cc
  parameters:
    tag_str: '"dab_sync"'
    vlen: '1'
  states: {}
- name: dab_diff_phasor_vcc_0
  id: dab_diff_phasor_vcc
  parameters:
    num_carriers: num_carriers__[dab_mode-1]
  states: {}
- name: dab_mer_0
  id: dab_mer
  parameters: {}
  states: {state: disabled}
- name: dab_moving_sum_ff_0
  id: dab_moving_sum_ff
  parameters:
    length: ns_length__[dab_mode-1]
  states: {}
- name: dab_ofdm_coarse_frequency_correct_0
  id: dab_ofdm_coarse_frequency_correct
  parameters:
    cp_length: cp_length__[dab_mode-1]
    fft_length: fft_length__[dab_mode-1]
    num_carriers: num_carriers__[dab_mode-1]
  states: {}
- name: dab_ofdm_ffe_all_in_one_0
  id: dab_ofdm_ffe_all_in_one
  parameters:
    alpha: '0.5'
    fft_length: fft_length__[dab_mode-1]
    num_symbols: symbols_for_ffs_estimation__[dab_mode-1]
    sample_rate: samp_rate
    symbol_length: fft_length__[dab_mode-1]+cp_length__[dab_mode-1]
  states: {}
- name: dab_ofdm_remove_first_symbol_vcc_0
  id: dab_ofdm_remove_first_symbol_vcc
  parameters:
    num_carriers: num_carriers__[dab_mode-1]
  states: {}
- name: dab_ofdm_sampler_0
  id: dab_ofdm_sampler
  parameters:
    cp_length: cp_length__[dab_mode-1]
    fft_length: fft_length__[dab_mode-1]
    gap: cp_gap__[dab_mode-1]
    symbols_per_frame: symbols_per_frame__[dab_mode-1]
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length__[dab_mode-1]
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Input Spectrum"'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Modulation Error
    max: '100'
    min: '0'
    name: '"Modulation Error"'
    type: float
    unit1: '% MER'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: I/Q
    name: '"I/Q Display"'
    size: '1024'
    srate: '1200000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: '68'
    freq0: 206.35e6
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', dab_moving_sum_ff_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_peak_detector_xb_0_0, '0']
- [blocks_multiply_xx_0, '0', dab_ofdm_sampler_0, '0']
- [blocks_peak_detector_xb_0_0, '0', dab_control_stream_to_tag_cc_0, '1']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [dab_control_stream_to_tag_cc_0, '0', blocks_delay_0, '0']
- [dab_control_stream_to_tag_cc_0, '0', dab_ofdm_ffe_all_in_one_0, '0']
- [dab_diff_phasor_vcc_0, '0', dab_ofdm_remove_first_symbol_vcc_0, '0']
- [dab_mer_0, '0', qtgui_number_sink_0, '0']
- [dab_moving_sum_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [dab_ofdm_coarse_frequency_correct_0, '0', dab_diff_phasor_vcc_0, '0']
- [dab_ofdm_ffe_all_in_one_0, '0', analog_frequency_modulator_fc_0, '0']
- [dab_ofdm_remove_first_symbol_vcc_0, '0', blocks_vector_to_stream_0, '0']
- [dab_ofdm_remove_first_symbol_vcc_0, '0', dab_mer_0, '0']
- [dab_ofdm_sampler_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', dab_ofdm_coarse_frequency_correct_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', dab_control_stream_to_tag_cc_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
