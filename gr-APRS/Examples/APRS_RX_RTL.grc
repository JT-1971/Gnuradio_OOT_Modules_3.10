options:
  parameters:
    author: Handiko
    description: www.github.com/handiko/gr-APRS
    generate_options: qt_gui
    id: APRS_RX_RTL
    output_language: python
    title: APRS - With RTL-SDR dongle
  states: {}

blocks:
- name: afgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: AF Gain (dB)
    min_len: '100'
    start: '-20'
    step: '0.1'
    stop: '-1'
    value: '-7'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: bb_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: dev_ppm
  id: variable
  parameters:
    value: '58'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 145.175e6
  states: {}
- name: gmu
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: RF Gain (dB)
    min_len: '100'
    start: '0'
    step: '1'
    stop: '62'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: space
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: APRS_Rx_0
  id: APRS_Rx
  parameters:
    baud: baud
    gmu: gmu
    mark: mark
    mu: mu
    samp_rate: ch_rate
    space: space
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: ch_rate/(2*math.pi*12e3/8.0)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-math.pi/2'
  states: {}
- name: display_text_msg_0
  id: display_text_msg
  parameters:
    label: ' ""'
    maxlines: '1000'
    messagekey: ''
    splitlength: '1000'
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.band_pass(1,ch_rate,400,5e3,400,2)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '32'
    corr0: dev_ppm
    freq0: freq
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: rfgain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: int(samp_rate / bb_rate)
    taps: '128'
  states: {}
- name: pfb_decimator_ccf_0_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: int(samp_rate / ch_rate)
    taps: '128'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.8'
    average: '0.2'
    bw: 192e3
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,2
    legend: 'False'
    name: RF Spectrum
    showports: 'True'
    type: complex
    width1: '2'
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.8'
    average: '0.2'
    bw: 8e3
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,2,2,1
    legend: 'False'
    name: AF Spectrum
    showports: 'True'
    type: float
    width1: '2'
    ymax: '20'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    legend: 'False'
    name: Clock Recovery
    size: '256'
    srate: '1200'
    type: float
    width1: '2'
    ymax: '2.1'
    ymin: '-2.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 192e3
    color1: '6'
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,2,1,1
    int_max: '-20'
    int_min: '-105'
    legend: 'False'
    name: RF Spectrum
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(ch_rate)
    interp: '8000'
    taps: ''
    type: fff
  states: {}

connections:
- [APRS_Rx_0, '0', qtgui_time_sink_x_0, '0']
- [APRS_Rx_0, HDLC, display_text_msg_0, text]
- [analog_quadrature_demod_cf_0, '0', fft_filter_xxx_1, '0']
- [blocks_rotator_cc_0, '0', pfb_decimator_ccf_0, '0']
- [blocks_rotator_cc_0, '0', pfb_decimator_ccf_0_0, '0']
- [fft_filter_xxx_1, '0', APRS_Rx_0, '0']
- [fft_filter_xxx_1, '0', audio_sink_0, '0']
- [fft_filter_xxx_1, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_rotator_cc_0, '0']
- [pfb_decimator_ccf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pfb_decimator_ccf_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [pfb_decimator_ccf_0_0, '0', qtgui_freq_sink_x_0, '0']
- [qtgui_freq_sink_x_0_0, freq, blocks_message_debug_0, print]
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
